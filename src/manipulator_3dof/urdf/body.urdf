Commit message: Update body.urdf

File: src/manipulator_3dof/urdf/body.urdf (robot description, URDF)
Before this commit: robot mainpulator_body, 4 links, 3 joints
Joints:
- joint link_1_to_link_2: origin xyz=0 0 0 rpy=0 0 0 -> xyz=0 0 5 rpy=0 0 0
